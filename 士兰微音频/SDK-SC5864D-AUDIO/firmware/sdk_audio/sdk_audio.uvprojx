# Keil uVision project sdk_audio.uvprojx, settings and files
target sdk_audio (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m0
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin .\obj\m0.axf --output .\obj\m0.bin
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: SC5864D
  c misc: --gnu --feedback fb.txt
  c include: .\sldrv\include;.\m0\include;.\main;.\m0\cache;.\USB_OTG_Driver\inc;.\USB_Device_Library\Core\inc;.\USB_Device_Library\Class\audio\inc;.\usb_audio
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: m0.sct
  link misc: --feedback fb.txt
  group m0
    ./m0/cache/: silan_m0_cache.c
    ./m0/src/: retarget.c silan_m0_irq_port.c SystemInit.c startup_CMSDK_CM0.s
  group main
    ./main/: main.c audio_proc.c
  group lib
    ./lib/: sldrv.lib usbaudio.lib
software components: CMSIS:CORE 5.0.1
